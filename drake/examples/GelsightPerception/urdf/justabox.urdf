Commit message: Rotating box demo working.

File: drake/examples/GelsightPerception/urdf/justabox.urdf (robot description, URDF)
Before this commit: robot myfirst, 1 links, 0 joints
Links:
- link base_link: mass None -> 0.5
